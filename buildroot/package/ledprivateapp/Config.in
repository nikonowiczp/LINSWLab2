## buildroot/package/ledprivateapp/Config.in
```kconfig
config BR2_PACKAGE_LEDPRIVATEAPP
	bool "ledprivateapp"
	help
		Moja prywatna aplikacja obslugujaca ledy :)
```
